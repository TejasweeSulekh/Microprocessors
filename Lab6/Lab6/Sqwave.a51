ORG 0h
LJMP MAIN
ORG 100H
    
	
MAIN:
CYCLE1:
    MOV P1, #00H
    MOV 30H, #2H
	MOV R0, 30H
	SETB P1.7	
	LCALL DELAY
	
CYCLE2:
	MOV R0, 30H
	CLR P1.7
	LCALL DELAY
	SJMP MAIN
	
DELAY:	
	LCALL CLK
	DJNZ R0, DELAY 
	RET
	
CLK:
	MOV R1,#02H
LOOP1:	
    CLR TF0
    DJNZ R1, TIMER
	RET
	
TIMER:	

    MOV TMOD, #01H
	MOV TH0, #0FAH
	MOV TL0, #0D4H
    SETB TR0

LOOP: JNB TF0, LOOP
    JMP LOOP1
	